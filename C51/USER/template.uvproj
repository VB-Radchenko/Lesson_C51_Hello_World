# Keil uVision project template.uvproj, settings and files
target TEMPLATE (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\Build.bat
  c flags: Optimize=3
  c include: ..\USER;..\FUNC_HANDLER;..\GUI_APP;..\HANDWARE\ADC;..\HANDWARE\GPIO;..\HANDWARE\PWM;..\HANDWARE\TIMER;..\HANDWARE\UART
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP_M5.A51 main.c sys.c
  group HANDWARE
    ../HANDWARE/ADC/: ADC.c
    ../HANDWARE/GPIO/: GPIO.c
    ../HANDWARE/TIMER/: TIMER.c
    ../HANDWARE/UART/: uart.c
